Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: Project Number
Time: 2023-06-21T16:56:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 21 16:56:04 2023 * Host: LIS-C-00085 * Database: C:\Users\MOA2OVR\AppData\Local\Temp\{55F0E40D-4B79-46BD-8B24-31E5118A8124}\ifc * Database version: 5507 * Database creation date: Wed Jun 21 16:56:02 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Jun 21 16:56:02 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 21 16:56:02 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionControlElement: SmartKey Reader with Keypad, Intrusion-Products_Bosch_SmartKey_Reader_with_Keypad:SmartKey_Reader_with_Keypad:212212
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_75_30_30_80 Smart card readers and writers (Uniclass 2015); Material: RAL 9010
Type - Constraints - Default Elevation: 2100 mm
Type - Dimensions - 2DSymbolOffset: 2 mm; Dimension depth (mm): 30; Dimension height (mm): 80; Dimension width (mm): 80
Type - General - Environmental class: 3; IP Class: IP65; Operating temperature (°C) (maximum): 60; Operating temperature (°C) (minimum): -25; Operating voltage (VDC) (maximum): 15; Operating voltage (VDC) (minimum): 12
Type - Identity Data - CTN: 4998113948; Description: SmartKey Reader with Keypad; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; InstallationManual: https://resources-boschsecurity-cdn.azureedge.net/public/documents/SmartKey_keypad_Installation_Manual_all_1434089227.pdf; Manufacturer: Bosch Security and Safety Systems; Material number: 4.998.113.948; OmniClass Number: 23.85.30.11.17; OmniClass Title: Electronic Key Systems; PlanningTools: https://resources-boschsecurity-cdn.azureedge.net/public/documents/SmartKey_keypad_Installation_Manual_all_1434089227.pdf; Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/SmartKey_keypad_Data_sheet_enUS_1434085643.pdf; Product Website: https://commerce.boschsecurity.com/nordics/en/SmartKey-code-keypad/p/4.998.113.948/; Type Name: SmartKey_Reader_with_Keypad
Type - Materials and Finishes - Color: Titanium white; Color in RAL: RAL9010; Material: ASA Luran S/Abs
Type - Other - Category: Security Devices; Family Name: Intrusion-Products_Bosch_SmartKey_Reader_with_Keypad
Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Volume: 0.000181598 m3
Identity Data - Mark: 8
Other - 2D_FlippedPosition: yes; 2D_OriginalPosition: no; Family: Intrusion-Products_Bosch_SmartKey_Reader_with_Keypad: SmartKey_Reader_with_Keypad; Family and Type: Intrusion-Products_Bosch_SmartKey_Reader_with_Keypad: SmartKey_Reader_with_Keypad; Schedule Level: Level: Level 1; Type: Intrusion-Products_Bosch_SmartKey_Reader_with_Keypad: SmartKey_Reader_with_Keypad; Type Id: Intrusion-Products_Bosch_SmartKey_Reader_with_Keypad: SmartKey_Reader_with_Keypad
Phasing - Phase Created: New Construction
